# Keil uVision project stm32-humidifier.uvprojx, settings and files
target target (6140000::V6.14::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32-humidifier
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: hum.c hum_sensor.c main.c mcu_init.c piezo.c systick.c utim.c wtim.c
  group inc
    ./: hum.h hum_sensor.h mcu_init.h piezo.h systick.h utim.h wtim.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
